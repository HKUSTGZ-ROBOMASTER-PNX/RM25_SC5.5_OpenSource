# Keil uVision project SCG4.uvprojx, settings and files
target SCG4 (6160000::V6.16::ARMCLANG)
  device: STM32G474CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SCG4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Core\BSP;..\Core\Controller;..\Core\Controller\BuckBoostController;..\Core\Entity;..\Core\Other;..\Core\Util
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: stm32g4xx_it.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_pwr.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_hal_rcc.c stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../Core/BSP/: bsp_adc.c bsp_20k_tim.c bsp_hrtim.c bsp_can.c bsp_led.c
  group MAIN
    ../Core/MAIN/: main.cpp
  group Controller
    ../Core/Controller/BuckBoostController/: BuckBoostController.cpp BuckBoostStateInit.cpp BuckBoostStatePowerLimited.cpp BuckBoostStateCurrentLimited.cpp
  group Util
    ../Core/Util/: Pid.cpp
  group Entity
    ../Core/Entity/: Multimeter.cpp
